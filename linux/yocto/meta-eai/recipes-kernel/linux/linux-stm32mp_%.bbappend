FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://usb-functionfs.cfg"
